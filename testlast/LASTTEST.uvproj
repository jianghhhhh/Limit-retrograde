# Keil uVision project LASTTEST.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S9B92 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LASTTEST
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: Startup.s main.c 1.c 2.c
    ./driverlib/rvmdk/: driverlib.lib
    ./grlib/rvmdk/: grlib.lib
    ./drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
